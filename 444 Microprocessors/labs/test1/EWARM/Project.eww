<<<<<<< HEAD
<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\test1.ewp</path>
  </project>
  <batchBuild />
</workspace>
=======
<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\test1.ewp</path>
  </project>
  <batchBuild />
</workspace>
>>>>>>> 57cca87149b6a2c58469570993efa5876b986ef6
